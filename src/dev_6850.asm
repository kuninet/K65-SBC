;;;
;;;	MCS6850 Console Driver
;;;

INIT:
	LDA	#ACIA_V1
	STA	ACIACS
	LDA	#ACIA_V2
	STA	ACIACS
	RTS
	
CONIN:
	LDA	ACIACS
	AND	#$01
	BEQ	CONIN
	LDA	ACIADT
	RTS
	
CONST:
	LDA	ACIACS
	AND	#$01
	RTS
	
CONOUT:
	PHA
CO0:
	LDA	ACIACS
	AND	#$02
	BEQ	CO0
	PLA
	STA	ACIADT
	RTS
